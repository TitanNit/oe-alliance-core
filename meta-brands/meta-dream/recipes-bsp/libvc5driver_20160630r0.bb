require libvc5driver.inc

SRC_URI[dm900.md5sum] = "15d78fd68d861b39f283c858b09c497a"
SRC_URI[dm900.sha256sum] = "f566ae2f2afd0a0706b28d86bac688131c60f57319f22a5dc231cad87ba71909"

PRECOMPILED_ARCH_arm = "dm900"

<<<<<<< HEAD
inherit opendreambox-precompiled-binary3
=======
inherit opendreambox-precompiled-binary2
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
