require recovery.inc

<<<<<<< HEAD
SRCREV = "160e6dcc0d3b08b1d6ab85f4b92e137a53fe231e"
=======
SRCREV = "2b939fdc1df56fc351a4a09fdfea0244b96e213c"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d

inherit opendreambox-git

BRANCH = "master"

COMPATIBLE_MACHINE = "^(dm520|dm820|dm900|dm7080)$"
