<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
PV="15.1"

require vuplus-platform-util.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "638005b798e68f4023ff2bc78738bf65"
SRC_URI[sha256sum] = "76bcf23abff166a878ce89729c2f8e68b3c425c4167c3017bb3d5bf5428b737b"
=======
SRC_URI[md5sum] = "c0bcb384d968e298ba989d586ec2693a"
SRC_URI[sha256sum] = "c733aa9db85026e8de498f4882bd8aec786868013030877f3fc23e514cd8f469"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
