<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
PV="15.1"

require vuplus-platform-util.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "d38046cf8bbc2ca4e44c8c02313a52de"
+SRC_URI[sha256sum] = "d8c3a1f3f82b8fc8ef34804d2867f2402fbe9cd0ff2e82b57a813523e454b20a"
=======
SRC_URI[md5sum] = "77535e227a9100d7bedae9734e09b9e1"
SRC_URI[sha256sum] = "94c59d71f09f04fefdce7f4440e2fa33d009a88adc930d2737404ef0a91cf48c"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
