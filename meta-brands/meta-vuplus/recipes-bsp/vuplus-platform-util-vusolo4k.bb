<<<<<<< HEAD
SRCDATE = "20170123"
=======
SRCDATE = "20161215"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
SRCDATE_PR = "r0"
PV="15.2"

require vuplus-platform-util.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "b43622ee9537c9735b1630de7107eef1"
SRC_URI[sha256sum] = "2fda2780ae5cbd8f588421929494487642ffc7c471e7046369a66625e1237c24"
=======
SRC_URI[md5sum] = "8a35cb36961a3b299856dcd81536da8b"
SRC_URI[sha256sum] = "feca5d2bcd602f85321bd4a1601e7fa664ca53a2c3cffa4c250d6f62aa33b2b8"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
