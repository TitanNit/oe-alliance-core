<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
PV="15.1"

require vuplus-platform-util.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "67503586616b33dc7a08446f3890241c"
SRC_URI[sha256sum] = "e03134a319d42bc37bd12366bfeab2de7ffbeb918b481bb194add689469b0ee9"
=======
SRC_URI[md5sum] = "1cb9edc1f2ceb27f9ecc38303d4c51a8"
SRC_URI[sha256sum] = "b0a8f209066a3ebfa1b3ac097f39b57b3ec4911cd48d24f280019351eb466e0a"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
