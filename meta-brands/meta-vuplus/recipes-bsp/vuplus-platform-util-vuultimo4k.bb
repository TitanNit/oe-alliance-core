require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

PV="16.1"
<<<<<<< HEAD
SRCDATE = "20170220"
=======
SRCDATE = "20161215"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
SRCDATE_PR = "r0"

S="${WORKDIR}/platform-util-vuultimo4k"

<<<<<<< HEAD
SRC_URI[md5sum] = "821a28f3e9d9dbff9e1ba27d90731339"
SRC_URI[sha256sum] = "355f69ed447c8010c9d2d42a36ed7ed2a635c5224ec3e32b60790b47be0dac19"
=======
SRC_URI[md5sum] = "2845b16326deaac5cabbe4a4c3762c3b"
SRC_URI[sha256sum] = "0ff3c643e1d77eb2470b6381466bf52ca8c29f0813ee5b5934d0a45f85664149"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
