require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

PV="16.1"
<<<<<<< HEAD
SRCDATE = "20170220"
=======
SRCDATE = "20161215"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
SRCDATE_PR = "r0"

S="${WORKDIR}/platform-util-vuuno4k"

<<<<<<< HEAD
SRC_URI[md5sum] = "b6c8cbf3112916c752f3bebd621f26de"
SRC_URI[sha256sum] = "0a9350e2e5a018a91993d46f908f45861aff19be1fc30e130529020c698bdc92"
=======
SRC_URI[md5sum] = "26560bce5a54d44f6a9bdfb457a8656b"
SRC_URI[sha256sum] = "4a727a711668221796097779b290de6a36293416a2fb640881e4b605445764b1"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
