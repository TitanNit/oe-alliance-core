<<<<<<< HEAD
SRCDATE = "20170224.r0"
=======
SRCDATE = "20161018.r0"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"


<<<<<<< HEAD
SRC_URI[md5sum] = "89e9a708745b1059f4739448b3fbc8e8"
SRC_URI[sha256sum] = "d54945529023b4b123c3f3cac99850b12b3abac2508eef8abbd40e0ecbde0cce"
=======
SRC_URI[md5sum] = "ae069cbbfeafb228f58374a17e9c1ef9"
SRC_URI[sha256sum] = "3171a57a2c2abc80aaaca9dd52fdaa6fe549008feadb04975dab476fc8674a02"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
