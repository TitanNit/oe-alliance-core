<<<<<<< HEAD
SRCDATE = "20170224.r0"
=======
SRCDATE = "20161018.r0"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d

require webkit-hbbtv-browser.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"


<<<<<<< HEAD
SRC_URI[md5sum] = "5ff40e197a39f94f0de481008173f160"
SRC_URI[sha256sum] = "d98ba016e3d0a1a80a79c7c456313ffd48f2cbb069ae6d2b73023e8eaf50b789"
=======
SRC_URI[md5sum] = "9eb98848424720f6e6c97a4253230fd5"
SRC_URI[sha256sum] = "66580fc3e8d5cd8971577fd333c0cdb29169ceccd44b37e27a5ed79660994adf"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
