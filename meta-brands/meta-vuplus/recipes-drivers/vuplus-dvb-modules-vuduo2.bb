KV = "3.13.5"
<<<<<<< HEAD
SRCDATE = "20161228"
=======
SRCDATE = "20161130"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d

require vuplus-dvb-modules.inc


<<<<<<< HEAD
SRC_URI[md5sum] = "43fe5cc2832a2cf5beb65aa41620dfb9"
SRC_URI[sha256sum] = "b004cd34b6ee2b58bfa2fec6f3c5fcd0dc76dae7f1ec9549b60148d124310042"
=======
SRC_URI[md5sum] = "cd7d87d3ebeef78f179312205ffb296c"
SRC_URI[sha256sum] = "a72c5efc10ed82f98189fa4fe3f06d8a9472c74d2a25d7a9f6cc7a8eff79d0fb"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
