KV = "3.13.5"
<<<<<<< HEAD
SRCDATE = "20161228"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "161127382bd9af10b9f097b644d995f9"
SRC_URI[sha256sum] = "e94ad502480006ed784a95c842311d4e44cafa186fd8051b0b0cdc0423dc8917"
=======
SRCDATE = "20161130"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "ea7140614156b898314e0b4c4aa73f8b"
SRC_URI[sha256sum] = "a6a1d7ae20f775f9c33301eb2936c6fc31efc0ae0720300c60fb657449459d3c"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
