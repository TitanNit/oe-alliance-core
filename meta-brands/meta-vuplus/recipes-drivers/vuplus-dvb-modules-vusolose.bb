KV = "3.13.5"
<<<<<<< HEAD
SRCDATE = "20161228"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "2176a2aabd9c65b5106a67f07d44db17"
SRC_URI[sha256sum] = "d227d3e6a564ae4fff7e6e1da6e5f7f92c6c5728cc1fa4f014b7cf915d3784e8"
=======
SRCDATE = "20161130"

require vuplus-dvb-modules.inc

SRC_URI[md5sum] = "21667dff380b2a70609d9714d1679c48"
SRC_URI[sha256sum] = "4b58f73f5246f1847a7aca9b96f32782d28f53cb9c0bf879019b121474c91192"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
