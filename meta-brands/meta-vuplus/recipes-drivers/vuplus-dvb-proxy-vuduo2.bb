KV = "3.13.5"
PV = "${KV}"
<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "152a2fe599f54a5c498cbeceb3af635a"
SRC_URI[sha256sum] = "f7dce0cf6dd059a0aea3529cfd2702967edd0bc62f123f72bd6bfcc00ac40f01"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "7c17190d5445b7b8c87dd94567cd23ea"
SRC_URI[sha256sum] = "dfe0432fdbd6f415ad1a9ff7dfd3f25b6158e2714ce75418aafdfad16b1aeb95"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
