KV = "3.13.5"
PV = "${KV}"
<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "83d3af56d27c828d52fd13e3964f0bd3"
SRC_URI[sha256sum] = "b375aadbf23cec6366325b3498d39fc5b01ebb6e8b5aca5b383a7c0ae983ffa0"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "f36c5f1705a7e7a2de0074d3f861265c"
SRC_URI[sha256sum] = "98404f399d03175a09af170057747fe6d1390696da046bdc06e0707938349d18"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
