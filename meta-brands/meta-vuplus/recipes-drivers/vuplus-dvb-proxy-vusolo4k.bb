PV = "3.14.28"
KV = "${PV}-1.8"
<<<<<<< HEAD
SRCDATE = "20170123"
=======
SRCDATE = "20161215"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
SRCDATE_PR = "r0"


require vuplus-dvb-proxy.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "87eb84c94bb5c0f20288c4038d473bc4"
SRC_URI[sha256sum] = "db2ea89f2629b2b7397550755ec9012b90e3380ce6921f3f6e2ddeb2c5708fbc"
=======
SRC_URI[md5sum] = "ca93cc4ba6d2e1c48e36047ca34b22a4"
SRC_URI[sha256sum] = "3c93f3ebd868d05ca601142e8d7e0504ad3c3a92f8c4bf05ceab9f247f2c3ab6"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d

