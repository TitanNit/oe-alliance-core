KV = "3.13.5"
PV = "${KV}"
<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "596b21f15580d9f9ff209ab6ea8ad7cf"
SRC_URI[sha256sum] = "0e2ffd9c95750f76c62d804d8aa2548feee9fc9a15d861108238f2186bf71ddc"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-dvb-proxy.inc

SRC_URI[md5sum] = "a9c949fb84d771e13819b0886bd721e9"
SRC_URI[sha256sum] = "b20e4216120847dd4c0aeb161ce1e91bae940d05bc15f9a74bb6eb193085af96"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
