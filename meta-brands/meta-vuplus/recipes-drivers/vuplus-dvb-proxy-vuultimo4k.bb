PV = "3.14.28"
KV = "${PV}-1.12"
<<<<<<< HEAD
SRCDATE = "20170220"
=======
SRCDATE = "20161215"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
SRCDATE_PR = "r0"

require vuplus-dvb-proxy.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "0417704119c13a0f1c1a15f176ad8760"
SRC_URI[sha256sum] = "ccaafe3abe85f8b0ffdb55db9b57cc42c8c055a7ad76b4b9a51785eb7c0ae168"
=======
SRC_URI[md5sum] = "0e157cb0c081a39251a5abdc4d6932be"
SRC_URI[sha256sum] = "74dcd1aac255e1eb4d678c79ceecd756791afae46c77e16e6e91d8f57ebb3692"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
