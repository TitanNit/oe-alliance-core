PV = "3.14.28"
KV = "${PV}-1.12"
<<<<<<< HEAD
SRCDATE = "20170220"
=======
SRCDATE = "20161215"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
SRCDATE_PR = "r0"

require vuplus-dvb-proxy.inc

<<<<<<< HEAD
SRC_URI[md5sum] = "c922f74f99f79008109882c90c566af1"
SRC_URI[sha256sum] = "03422610bb9af7b950bb32cac66b20656d4c818079d443981a0f1b0d4b09e48e"
=======
SRC_URI[md5sum] = "5d765892677d4cac08b24f8d68361c13"
SRC_URI[sha256sum] = "b16e3d1e392abcdbb2b8562beb072ca508e23919c9a3134c99671be7387754e2"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
