<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"

require vuplus-libgles.inc

SRC_URI[md5sum] = "a5292a513f652d2b6f15498a71993328"
SRC_URI[sha256sum] = "391a2f0c3de3600f9724a48e09c50a6f039c45550272e4d1798fd6d101ec3688"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-libgles.inc

SRC_URI[md5sum] = "32fae0e0ba480a7ed4e9cec1e4dcbd30"
SRC_URI[sha256sum] = "7f72cc53dbd2bf68039f87d98f2b956e98c6f31e0d807a8b8f2486bbb23fbfa6"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
