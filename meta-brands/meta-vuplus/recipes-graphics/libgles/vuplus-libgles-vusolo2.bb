<<<<<<< HEAD
SRCDATE = "20161228"
SRCDATE_PR = "r0"

require vuplus-libgles.inc

SRC_URI[md5sum] = "10814738e99535903d491737664f411f"
SRC_URI[sha256sum] = "13b526e13ad4f244f610c5f3245100335880f970008131a62cd4a84092568570"
=======
SRCDATE = "20161130"
SRCDATE_PR = "r1"

require vuplus-libgles.inc

SRC_URI[md5sum] = "a7a204563f204d771f744f6571914fd5"
SRC_URI[sha256sum] = "83edbe4c9062bbd968bbc5a17cb330591f36ef4e24b708caf5e11c5a987d6d09"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
