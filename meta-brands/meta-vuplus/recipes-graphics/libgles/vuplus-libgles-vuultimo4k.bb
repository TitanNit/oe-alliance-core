require vuplus-libgles.inc

<<<<<<< HEAD
SRCDATE = "20170220"
SRCDATE_PR = "r0"
PV="16.1"

SRC_URI[md5sum] = "4f278c7c9b3384bc9305c3b2cd8871ed"
SRC_URI[sha256sum] = "7cc99e7a507ae09f25637e077c1284fe9709e6b84ac9c17b949ff5bc91682a23"
=======
SRCDATE = "20161215"
SRCDATE_PR = "r0"
PV="16.1"

SRC_URI[md5sum] = "eb84d640ad9ab631f579c4a80de86d32"
SRC_URI[sha256sum] = "aba747cdcf0cc35daa0aa6ca450410f48feed7558ec212d3421020d3be93f366"
>>>>>>> 4f58c88e9d0ec24aca8360de76c49e6d42d1d72d
